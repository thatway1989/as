<?xml version='1.0' encoding='utf-8'?>

<AUTOSAR>
<OS>
<General CPU_CORE_NUMBER="1" Comment="Not Used" Conformance="ECC1" ErrorHook="ErrorHook" PTHREAD="32" PTHREAD_PRIORITY="32" PostTaskHook="PostTaskHook" PreTaskHook="PreTaskHook" ProtectionHook="NULL" ShutdownHook="ShutdownHook" StartupHook="StartupHook" Status="EXTENDED" />
<ApplicationModeList Max="TBD">
<ApplicationMode Comment="*" Name="OSDEFAULTAPPMODE" />
</ApplicationModeList>
<ApplicationList Max="TBD">
<Application Comment="*" Name="OsDefaultApp" RestartTask="SchM_Startup" Trusted="True" UseRestartTask="True" />
</ApplicationList>
<TaskList Max="TBD">
<Task Activation="1" Application="OsDefaultApp" Autostart="True" Comment="*" Cpu="OS_ON_ANY_CPU" Name="SchM_Startup" Priority="7" Schedule="FULL" StackSize="2048">
<ApplicationModeList Max="TBD">
<ApplicationMode Comment="*" Name="OSDEFAULTAPPMODE" />
</ApplicationModeList>
</Task>
<Task Activation="1" Application="OsDefaultApp" Autostart="False" Comment="*" Cpu="OS_ON_ANY_CPU" Name="SchM_BswService" Priority="8" Schedule="FULL" StackSize="2048" />
<Task Activation="1" Application="OsDefaultApp" Autostart="True" Comment="*" Cpu="OS_ON_ANY_CPU" Name="TaskIdle" Priority="0" Schedule="FULL" StackSize="2048">
<ApplicationModeList Max="TBD">
<ApplicationMode Comment="*" Name="OSDEFAULTAPPMODE" />
</ApplicationModeList>
</Task>
</TaskList>
<AlarmList Max="TBD">
<Alarm Action="ActivateTask" Application="OsDefaultApp" Autostart="False" Callback="TBD" Comment="*" Counter="OsClock" Event="TBD" Name="Alarm_BswService" Period="100" StartTime="0" Task="SchM_BswService" />
</AlarmList>
<CounterList Max="TBD">
<Counter Application="OsDefaultApp" Comment="*" MaxAllowed="0xFFFF" MinCycle="1" Name="OsClock" TicksPerBase="1" />
</CounterList>
<ResourceList Max="TBD">
<Resource Application="TBD" Comment="*" Name="RES_SCHEDULER" Priority="15" />
</ResourceList>
<InternalResourceList Max="TBD" />
</OS>
<EcuC>
<PduList Max="TBD">
<Pdu Comment="*" Name="RxLinDiag" Size="64" />
<Pdu Comment="*" Name="TxLinDiag" Size="64" />
<Pdu Comment="virtual LinTp PDU" Name="RxLinDiagTp" Size="64" />
<Pdu Comment="virtual LinTp PDU" Name="TxLinDiagTp" Size="64" />
</PduList>
</EcuC>
<Can>
<General Comment="*" DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" />
<ControllerList Max="TBD" />
</Can>
<CanIf>
<General BusOffNotification="CanIf_User_BusoffNotification" Comment="*" DataLengthCodeCheck="ON" DevelopmentErrorDetection="OFF" ErrorNotification="CanIf_User_ErrorNotification" RxFifoSize="32" TaskFifoMode="ON" TxFifoSize="32" VersionInfoApi="OFF" />
<ChannelList Max="TBD" />
</CanIf>
<CanTp>
<General Comment="*" DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" />
<RxSduList Max="TBD" />
<TxSduList Max="TBD" />
</CanTp>
<PduR>
<General CanIfUsed="False" CanTpUsed="False" ComUsed="False" Comment="*" DcmUsed="True" DevelopmentErrorDetection="ON" J1939TpUsed="False" LinIfUsed="True" LinTpUsed="True" VersionInfoApi="OFF" ZeroCostIf="CanIf" ZeroCostOperationMode="OFF" ZeroCostTp="CanTp" />
<RoutineList Max="TBD">
<Source Comment="*" Module="Dcm" Name="DcmP2P" PduRef="TxLinDiagTp">
<DestinationList Max="TBD">
<Destination Comment="*" Module="LinSTp" Name="LinTpP2P" PduRef="TxLinDiagTp" />
</DestinationList>
</Source>
<Source Comment="*" Module="LinSTp" Name="LinTpP2P" PduRef="RxLinDiagTp">
<DestinationList Max="TBD">
<Destination Comment="*" Module="Dcm" Name="DcmP2P" PduRef="RxLinDiagTp" />
</DestinationList>
</Source>
<Source Comment="*" Module="LinIf" Name="RxLinIfToTp" PduRef="RxLinDiag">
<DestinationList Max="TBD">
<Destination Comment="*" Module="LinSTp" Name="RxLinIfToTp" PduRef="RxLinDiag" />
</DestinationList>
</Source>
<Source Comment="*" Module="LinSTp" Name="TxLinTpToLinIf" PduRef="TxLinDiag">
<DestinationList Max="TBD">
<Destination Comment="*" Module="LinIf" Name="TxLinTpToLinIf" PduRef="TxLinDiag" />
</DestinationList>
</Source>
</RoutineList>
</PduR>
<Com>
<General Comment="*" DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" />
<PduGroupList Max="TBD" />
<IPduList Max="TBD" />
</Com>
<Dcm>
<General Comment="*" DevelopmentErrorDetection="ON" MaxPeriodDIDNumber="8" PeriodicDIDFastModeTime="50" PeriodicDIDMediumModeTime="100" PeriodicDIDSlowModeTime="200" VersionInfoApi="OFF" />
<BufferList Max="TBD">
<Buffer Comment="*" Name="Buffer1" Size="512" />
<Buffer Comment="*" Name="Buffer2" Size="512" />
</BufferList>
<SessionList Max="TBD">
<Session Comment="*" Identifier="1" Name="DS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" />
<Session Comment="*" Identifier="2" Name="PRGS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" />
<Session Comment="*" Identifier="3" Name="EXTDS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" />
</SessionList>
<SecurityList Max="TBD">
<Security Comment="*" CompareKeyCallback="NULL" GetSeedCallback="NULL" Identifier="6" KeySize="4" Name="PRGS" SeedSize="4" />
<Security Comment="*" CompareKeyCallback="Diag_CompareKeyEXTDS" GetSeedCallback="Diag_GetSeedEXTDS" Identifier="1" KeySize="4" Name="EXTDS" SeedSize="4" />
<Security Comment="Level 0, is the default for each session when enterred" CompareKeyCallback="NULL" GetSeedCallback="NULL" Identifier="0" KeySize="4" Name="DS" SeedSize="4" />
</SecurityList>
<DIDControlRecordList Max="TBD" />
<DIDInfoList Max="TBD" />
<DIDList Max="TBD" />
<RoutineInfoList Max="TBD" />
<RoutineList Max="TBD" />
<MemoryList Max="TBD" />
<ProtocolList Max="TBD">
<Protocol Comment="*" Name="P2P" ProtocolID="UDS_ON_CAN" RxBufferRef="Buffer1" ServiceTableRef="ServiceTableP2P" TimingLimitRef="Timing1" TransmissionType="TYPE_1" TxBufferRef="Buffer2">
<ConnectionList Max="TBD">
<Connection Comment="*" Name="Connection1">
<RxChannelList Max="TBD">
<RxChannel AddressingType="PHYSICAL" Comment="*" Name="RxChannel1" PduRef="RxLinDiagTp" />
</RxChannelList>
<TxChannel Comment="*" Name="TxChannel2" PduRef="TxLinDiagTp" />
</Connection>
</ConnectionList>
</Protocol>
</ProtocolList>
<RequestServiceList Max="TBD">
<RequestService Comment="*" Name="RequestService1" ProtocolIndicationCbk="Diag_ProtocolIndicationCbk" StartProtocolCbk="Diag_StartProtocolCbk" StopProtocolCbk="Diag_StopProtocolCbk" />
</RequestServiceList>
<ServiceTableList Max="TBD">
<ServiceTable Comment="*" Name="ServiceTableP2P">
<ServiceList Max="TBD">
<Service Comment="*" Name="DIAGNOSTIC_SESSION_CONTROL" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="DS" />
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="DS" />
<Session Comment="*" Name="PRGS" />
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="SECURITY_ACCESS" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="DS" />
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="TESTER_PRESENT" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="DS" />
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="ECU_RESET" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="READ_DATA_BY_IDENTIFIER" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="EXTDS" />
<Security Comment="*" Name="PRGS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="EXTDS" />
<Session Comment="*" Name="PRGS" />
</SessionList>
</Service>
<Service Comment="*" Name="READ_DTC_INFORMATION" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="CLEAR_DIAGNOSTIC_INFORMATION" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
</ServiceList>
</ServiceTable>
<ServiceTable Comment="*" Name="ServiceTableP2A">
<ServiceList Max="TBD">
<Service Comment="*" Name="DIAGNOSTIC_SESSION_CONTROL" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="EXTDS" />
<Security Comment="*" Name="DS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="EXTDS" />
<Session Comment="*" Name="DS" />
</SessionList>
</Service>
<Service Comment="*" Name="TESTER_PRESENT" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="EXTDS" />
<Security Comment="*" Name="DS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="DS" />
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
</ServiceList>
</ServiceTable>
</ServiceTableList>
<SessionControlList Max="TBD">
<SessionControl Comment="*" GetSessionChangePermissionCbk="Diag_GetSesChgPer" Name="SessionControl1" />
</SessionControlList>
<TimingList Max="TBD">
<Timing Comment="*" Name="Timing1" P2ServerMaxTimeMs="5000" P2ServerMinTimeMs="3000" S3ServerTimeMs="10000" />
</TimingList>
</Dcm>
<Fls>
<General Comment="*" DevelopmentErrorDetection="OFF" FlashBaseAddress="0" MaxFastReadSize="512" MaxFastWriteSize="32" MaxNormalReadSize="32" MaxNormalWriteSize="8" VersionInfoApi="OFF" />
<SectorList Max="TBD" />
</Fls>
<Fee>
<General Comment="*" DevelopmentErrorDetection="OFF" NvmJobEndNotification="NULL" NvmJobErrorNotification="NULL" PollingMode="ON" VersionInfoApi="OFF" VirtualPageSize="8" />
<BlockList Max="TBD" />
</Fee>
<Ea>
<General Comment="*" DevelopmentErrorDetection="OFF" NvmJobEndNotification="NULL" NvmJobErrorNotification="NULL" SetModeApi="ON" VersionInfoApi="OFF" VirtualPageSize="8" />
<BlockList Max="TBD" />
</Ea>
<NvM>
<General Comment="*" ConfigClass="CLASS_2" DevelopmentErrorDetection="OFF" ImmediateJobQueueSize="8" MultiBlockCallback="NULL" PollingMode="ON" RamBlockStatusApi="ON" StandardJobQueueSize="8" VersionInfoApi="OFF" />
<BlockList Max="TBD" />
</NvM>
<Xcp>
<General Comment="*" DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" XcpCounterRef="TBD" XcpDaqConfigType="DAQ_STATIC" XcpDaqCount="8" XcpFlashProgrammingEnabled="True" XcpIdentificationFieldType="ABSOLUTE" XcpMainFunctionPeriod="10" XcpMaxCto="8" XcpMaxDto="8" XcpMaxEventChannel="8" XcpMaxRxTxQueue="0" XcpMinDaq="0" XcpNvRamBlockIdRef="TBD" XcpOdtCount="56" XcpOdtEntriesCount="112" XcpOdtEntrySizeDaq="0" XcpOdtEntrySizeStim="0" XcpPrescalerSupported="True" XcpProtocal="CAN" XcpSuppressTxSupport="True" XcpTimestampTicks="1" XcpTimestampType="FOUR_BYTE" XcpTimestampUnit="1ms" />
<XcpStaticDaqList Max="TBD" />
<XcpEventChannelList Max="TBD" />
</Xcp>
<Rte>
<DataTypeList Max="TBD" />
<ConstantList Max="TBD" />
<SwcList Max="TBD" />
</Rte>
<Dem>
<General Comment="*" DEM_CLEAR_ALL_EVENTS="OFF" DEM_DTC_STATUS_AVAILABILITY_MASK="0xFF" DEM_MAX_NUMBER_FF_DATA_PRI_MEM="5" DEM_OBD_SUPPORT="OFF" DEM_PTO_SUPPORT="OFF" DEM_TYPE_OF_DTC_SUPPORTED="0x01" DEM_USE_NVM="ON" DevelopmentErrorDetection="OFF" NvMFreezeFrameBlock="TBD" NvMHealingBlock="TBD" VersionInfoApi="OFF" />
<ExtendedDataRecordClassList Max="TBD" />
<DTCClassList Max="TBD" />
<FFIdClassList Max="TBD" />
<FreezeFrameClassList Max="TBD" />
<EventClassList Max="TBD" />
<EventParameterList Max="TBD" />
</Dem>
<J1939Tp>
<General Comment="*" DevelopmentErrorDetection="OFF" PACKETS_PER_BLOCK="8" TX_CONF_TIMEOUT="1000" VersionInfoApi="OFF" />
<ChannelList Max="TBD" />
<ParameterGroupList Max="TBD" />
<PduInfoList Max="TBD" />
</J1939Tp>
</AUTOSAR>
